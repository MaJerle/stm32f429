# Keil uVision project project.uvprojx, settings and files
target STM32F4-Discovery (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F4XX,KEIL_IDE,TM_DISCO_STM32F4_DISCOVERY,PLL_M=8,PLL_N=336,PLL_P=2,PLL_Q=7,HSE_VALUE=8000000
  c include: .\User;.\TM;..\00-STM32F429_LIBRARIES;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\inc;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\src;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Include;..\00-STM32F429_LIBRARIES\lwip\src\include;..\00-STM32F429_LIBRARIES\lwip\src\include\lwip;..\00-STM32F429_LIBRARIES\lwip\src\include\netif;..\00-STM32F429_LIBRARIES\lwip\src\include\ipv4;..\00-STM32F429_LIBRARIES\lwip\port;..\00-STM32F429_LIBRARIES\lwip;..\00-STM32F429_LIBRARIES\lwip\client;..\00-STM32F429_LIBRARIES\lwip\server;..\00-STM32F429_LIBRARIES\fatfs;..\00-STM32F429_LIBRARIES\fatfs\drivers;..\00-STM32F429_LIBRARIES\fatfs\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group Startup
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s startup_stm32f401xx.s startup_stm32f411xe.s startup_stm32f429_439xx.s
  group STD_Periph_Drivers
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_iwdg.c
  group TM
    ../00-STM32F429_LIBRARIES/: tm_stm32f4_delay.h tm_stm32f4_delay.c tm_stm32f4_disco.h tm_stm32f4_disco.c tm_stm32f4_usart.c tm_stm32f4_usart.h tm_stm32f4_ethernet.c tm_stm32f4_ethernet.h tm_stm32f4_rtc.c tm_stm32f4_rtc.h tm_stm32f4_watchdog.c tm_stm32f4_watchdog.h tm_stm32f4_gpio.c tm_stm32f4_gpio.h
  group User
    ./User/: main.h main.c defines.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group Ethernet Server
    ../00-STM32F429_LIBRARIES/lwip/: fs.c fs.h fsdata.c fsdata.h httpd.c httpd.h httpd_structs.h
  group Ethernet Client
    ../00-STM32F429_LIBRARIES/lwip/: tcp_echoclient.c tcp_echoclient.h
  group Ethernet
    ../00-STM32F429_LIBRARIES/lwip/: netconf.c stm32f4x7_eth.c stm32f4x7_eth_bsp.c
    ../00-STM32F429_LIBRARIES/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../00-STM32F429_LIBRARIES/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../00-STM32F429_LIBRARIES/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../00-STM32F429_LIBRARIES/lwip/src/netif/: etharp.c ethernetif.c slipif.c
    ../00-STM32F429_LIBRARIES/lwip/port/: ethernetif.h
target STM32F429I-Discovery (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,STM32F4XX,KEIL_IDE,TM_DISCO_STM32F429_DISCOVERY,HSE_VALUE=8000000,PLL_M=8,PLL_N=336,PLL_P=2,PLL_Q=7
  c include: .\User;.\TM;..\00-STM32F429_LIBRARIES;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\inc;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\src;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Include;..\00-STM32F429_LIBRARIES\lwip\src\include;..\00-STM32F429_LIBRARIES\lwip\src\include\lwip;..\00-STM32F429_LIBRARIES\lwip\src\include\netif;..\00-STM32F429_LIBRARIES\lwip\src\include\ipv4;..\00-STM32F429_LIBRARIES\lwip\port;..\00-STM32F429_LIBRARIES\lwip;..\00-STM32F429_LIBRARIES\lwip\client;..\00-STM32F429_LIBRARIES\lwip\server
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F4x9-EVAL (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: as above
  output: project +hex
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,STM32F4XX,KEIL_IDE,TM_DISCO_STM32F4x9_EVAL,HSE_VALUE=8000000,PLL_M=8,PLL_N=336,PLL_P=2,PLL_Q=7,ETHERNET_MII_MODE,ETHERNET_USE_DHCP
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
