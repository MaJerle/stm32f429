# Keil uVision project project.uvprojx, settings and files
target STM32F4-Discovery (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000,TM_DISCO_STM32F4_DISCOVERY
  c include: .\TM;.\User;..\00-STM32F429_LIBRARIES;..\00-STM32F429_LIBRARIES\usb_msc_host;..\00-STM32F429_LIBRARIES\usb_msc_host\fatfs;..\00-STM32F429_LIBRARIES\usb_msc_host\fatfs\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group TM
    ../00-STM32F429_LIBRARIES/: tm_stm32f4_disco.h tm_stm32f4_disco.c tm_stm32f4_delay.h tm_stm32f4_delay.c tm_stm32f4_usb_msc_host.h tm_stm32f4_usb_msc_host.c
  group User
    ./User/: defines.h main.c stm32f4xx_conf.h
  group USB
    ../00-STM32F429_LIBRARIES/usb_msc_host/: usb_bsp.c usb_bsp.h usb_conf.h usb_conf_template.h usb_core.c usb_core.h usb_dcd.c usb_dcd.h usb_dcd_int.h usb_defines.h usb_hcd.c usb_hcd.h usb_hcd_int.c usb_hcd_int.h usb_regs.h usbh_conf.h usbh_core.c usbh_core.h usbh_def.h usbh_hcs.c usbh_hcs.h usbh_ioreq.c usbh_ioreq.h usbh_msc_bot.c usbh_msc_bot.h usbh_msc_core.c usbh_msc_core.h usbh_msc_scsi.c usbh_msc_scsi.h usbh_stdreq.c usbh_stdreq.h usbh_usr.c usbh_usr.h
  group FATFS
    ../00-STM32F429_LIBRARIES/usb_msc_host/fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ../00-STM32F429_LIBRARIES/usb_msc_host/fatfs/option/: syscall.c unicode.c
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.1.1/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/Device/StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_usart.c
    RTE/Device/STM32F407VG/: RTE_Device.h startup_stm32f40_41xxx.s stm32f4xx_conf.h system_stm32f4xx.c
    RTE/Device/STM32F401RE/: RTE_Device.h startup_stm32f401xx.s stm32f4xx_conf.h system_stm32f4xx.c
    RTE/Device/STM32F429ZI/: RTE_Device.h startup_stm32f429_439xx.s stm32f4xx_conf.h system_stm32f4xx.c
target STM32F429-Discovery (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000,TM_DISCO_STM32F429_DISCOVERY,USE_USB_OTG_HS
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Nucleo F401RE (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000,TM_DISCO_NUCLEO_F401
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 3.30.0, CMSIS:DSP 1.4.2, Device:Startup 1.3.1, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
