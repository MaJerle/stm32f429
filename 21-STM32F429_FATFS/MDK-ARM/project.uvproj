# Keil uVision project project.uvproj, settings and files
target STM32F429 ZI (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: project +hex
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,__ASSEMBLY__,KEIL_IDE,TM_DISCO_STM32F4_DISCOVERY
  c include: ..\CMSIS;..\User;..\MDK-ARM;..\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4xx_StdPeriph_Driver\src;..\..\00-STM32F429_LIBRARIES;..\..\00-STM32F429_LIBRARIES\fatfs;..\..\00-STM32F429_LIBRARIES\fatfs\drivers
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c stm32f4xx.h system_stm32f4xx.h core_cmInstr.h core_cmFunc.h core_cm4.h
  group MDK-ARM
    ./: startup_stm32f429_439xx.s
  group STD Periph
    ../STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_i2c.c
  group TM
    ../../00-STM32F429_LIBRARIES/: tm_stm32f4_delay.c tm_stm32f4_delay.h tm_stm32f4_disco.c tm_stm32f4_disco.h tm_stm32f4_usart.h tm_stm32f4_usart.c tm_stm32f4_fatfs.c tm_stm32f4_fatfs.h tm_stm32f4_spi.c tm_stm32f4_spi.h tm_stm32f4_ili9341.h tm_stm32f4_ili9341.c tm_stm32f4_fonts.h tm_stm32f4_fonts.c tm_stm32f4_ds1307.c tm_stm32f4_ds1307.h tm_stm32f4_i2c.c tm_stm32f4_i2c.h
    ../../00-STM32F429_LIBRARIES/fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ../../00-STM32F429_LIBRARIES/fatfs/drivers/: fatfs_sd.c fatfs_sd.h fatfs_sd_sdio.c fatfs_sd_sdio.h
    ../../00-STM32F429_LIBRARIES/fatfs/option/: unicode.c syscall.c
  group User
    ../User/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h defines.h
    ./: main.h
